# Keil uVision project HID.uvproj, settings and files
target QITAS (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: VCK1 +hex
  c flags: Optimize=6 SizeSpeed=1
  group HID
    ./usr/: main.c Key.c USB.c DEBUG.C
